# Keil uVision project Project.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: control +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\Start;.\Library;.\User;.\System;.\Hardware;.\RTT;.\Component\fal\inc;.\Component\FlashDB\inc;.\Component\SFUD\sfud\inc;.\Component\fal\samples\porting;.\Component\XMODEM;.\Component\ymodem;.\Component\modbus\modbus\ascii;.\Component\modbus\modbus\functions;.\Component\modbus\modbus\include;.\Component\modbus\modbus\rtu;.\Component\modbus\slave;.\Component\ymodem;.\Component\modbus\modbus;.\Component\modbus\master\inc;.\Component\modbus\master;.\Component\modbus\modbus\tcp;.\Component\PID\inc;.\Component\AT;.\Component\cJSON-v1.7.17
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Start
    ./Start/: core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h startup_stm32f10x_hd.s
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group Hardware
    ./Hardware/: MyRTC.c MyRTC.h W25Q64Flash.c W25Q64Flash.h TIM.c TIM.h iwdog.c iwdog.h uart.c uart.h spi.c spi.h GPIO.c GPIO.h
  group User
    ./User/: main.c main.h stm32f10x_it.c stm32f10x_it.h user_DB.c stm32f10x_conf.h user_DB.h
  group RTT
    ./RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c log.h SEGGER_RTT.h
  group FlashDB
    ./Component/fal/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
    ./Component/fal/samples/porting/: fal_cfg.h fal_flash_sfud_port.c
    ./Component/FlashDB/src/: fdb.c fdb_file.c fdb_kvdb.c fdb_tsdb.c fdb_utils.c
    ./Component/SFUD/sfud/src/: sfud.c sfud_sfdp.c
    ./Component/SFUD/sfud/port/: sfud_port.c
    ./Component/FlashDB/port/fal/samples/porting/: fal_flash_stm32f1_port.c
  group freemodbus/modbus
    ./Component/modbus/modbus/rtu/: mbcrc.c
    ./Component/modbus/modbus/functions/: mbfuncother.c mbutils.c
  group freemodbus/slave
    ./Component/modbus/slave/: mb.c mbfunccoils.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbrtu.c portevent.c portserial.c porttimer.c slave_mb_app.c slave_mb_app.h
    ./Component/modbus/modbus/ascii/: mbascii.c
  group freemodbus/master
    ./Component/modbus/master/: master_mb_app.c master_mb_app.h
    ./Component/modbus/master/inc/: agile_modbus.h agile_modbus_rtu.h agile_modbus_tcp.h
    ./Component/modbus/master/src/: agile_modbus.c agile_modbus_rtu.c agile_modbus_tcp.c
  group PID
    ./Component/PID/src/: qpid.c
  group AT
    ./Component/AT/: AT_Device.c AT_Device.h AT_Cmd.c AT_Cmd.h
    ./Component/cJSON-v1.7.17/: cJSON.c cJSON.h cJSON_Utils.c cJSON_Utils.h user_cjson.c user_cjson.h
software components: RTOS:kernel 3.1.5, RTOS:shell 3.1.5
